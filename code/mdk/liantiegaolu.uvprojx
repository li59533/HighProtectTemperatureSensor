# Keil uVision project liantiegaolu.uvprojx, settings and files
target Normal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL16Z64xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFF800,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: liantiegaolu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MKL16Z64VFM4
  c include: ..\components\MKL16Z4\drivers;..\components\MKL16Z4;..\components\MKL16Z4\arm;..\mdl;..\bsp;..\components\MKL16Z4\utilities;..\components\CMSIS\Include;..\mdl\rttviewer;..\mdl\osal\ports;..\mdl\osal\src;..\task;..\fml;..\Utilities;..\app
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: ..\components\MKL16Z4\arm\MKL16Z64xxx4_flash.scf
  link misc: --remove
  group component/startup
    ../components/MKL16Z4/arm/: startup_MKL16Z4.s
    ../components/MKL16Z4/: system_MKL16Z4.c system_MKL16Z4.h
  group component/utilities
    ../components/MKL16Z4/utilities/: fsl_debug_console.c
  group component/dirver
    ../components/MKL16Z4/drivers/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_dac.c fsl_dma.c fsl_dmamux.c fsl_flash.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_llwu.c fsl_lpsci.c fsl_lpsci_dma.c fsl_lptmr.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sim.c fsl_smc.c fsl_spi.c fsl_spi_dma.c fsl_tpm.c fsl_tsi_v4.c fsl_uart.c fsl_uart_dma.c fsl_port.h
    ../components/MKL16Z4/: fsl_device_registers.h MKL16Z4_features.h MKL16Z4.h
  group app
    ../app/: main.c app_getdata.c app_transfer.c app_revmessage.c app_conf.c app_battery.c
  group bsp
    ../bsp/: bsp_conf.h bsp_led.c bsp_uart.c bsp_tim.c bsp_rtc.c bsp_adc.c bsp_flash.c bsp_systick.c bsp_clock.c bsp_e32.c bsp_power.c bsp_lmt01.c
  group fml
    ../fml/: system_param.c lnprotocol.c lnprotocol_std.c version.c
  group mdl
    ../mdl/: board.c self_def.h
    ../mdl/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../mdl/osal/src/: osal.c osal_cfg.c osal_clock.c osal_core.c osal_msg.c osal_task.c osal_timeout.c osal_timer.c
  group task
    ../task/: hal_task.c user_task.c net_task.c app_task.c
  group utilities
    ../Utilities/: crc.c
